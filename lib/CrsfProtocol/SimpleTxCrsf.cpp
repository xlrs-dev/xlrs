/*
 * Bit-for-bit CRSF frame encoding cloned from Arduino-Transmitter-for-ELRS SimpleTX
 * https://github.com/kkbin505/Arduino-Transmitter-for-ELRS SimpleTX/crsf.cpp — GPLv3+
 */

#include "SimpleTxCrsf.h"

namespace simpletx_crsf {

namespace {

// crc implementation from CRSF protocol document rev7 (SimpleTX)
const uint8_t crsf_crc8tab[256] = {
    0x00, 0xD5, 0x7F, 0xAA, 0xFE, 0x2B, 0x81, 0x54, 0x29, 0xFC, 0x56, 0x83, 0xD7, 0x02, 0xA8, 0x7D,
    0x52, 0x87, 0x2D, 0xF8, 0xAC, 0x79, 0xD3, 0x06, 0x7B, 0xAE, 0x04, 0xD1, 0x85, 0x50, 0xFA, 0x2F,
    0xA4, 0x71, 0xDB, 0x0E, 0x5A, 0x8F, 0x25, 0xF0, 0x8D, 0x58, 0xF2, 0x27, 0x73, 0xA6, 0x0C, 0xD9,
    0xF6, 0x23, 0x89, 0x5C, 0x08, 0xDD, 0x77, 0xA2, 0xDF, 0x0A, 0xA0, 0x75, 0x21, 0xF4, 0x5E, 0x8B,
    0x9D, 0x48, 0xE2, 0x37, 0x63, 0xB6, 0x1C, 0xC9, 0xB4, 0x61, 0xCB, 0x1E, 0x4A, 0x9F, 0x35, 0xE0,
    0xCF, 0x1A, 0xB0, 0x65, 0x31, 0xE4, 0x4E, 0x9B, 0xE6, 0x33, 0x99, 0x4C, 0x18, 0xCD, 0x67, 0xB2,
    0x39, 0xEC, 0x46, 0x93, 0xC7, 0x12, 0xB8, 0x6D, 0x10, 0xC5, 0x6F, 0xBA, 0xEE, 0x3B, 0x91, 0x44,
    0x6B, 0xBE, 0x14, 0xC1, 0x95, 0x40, 0xEA, 0x3F, 0x42, 0x97, 0x3D, 0xE8, 0xBC, 0x69, 0xC3, 0x16,
    0xEF, 0x3A, 0x90, 0x45, 0x11, 0xC4, 0x6E, 0xBB, 0xC6, 0x13, 0xB9, 0x6C, 0x38, 0xED, 0x47, 0x92,
    0xBD, 0x68, 0xC2, 0x17, 0x43, 0x96, 0x3C, 0xE9, 0x94, 0x41, 0xEB, 0x3E, 0x6A, 0xBF, 0x15, 0xC0,
    0x4B, 0x9E, 0x34, 0xE1, 0xB5, 0x60, 0xCA, 0x1F, 0x62, 0xB7, 0x1D, 0xC8, 0x9C, 0x49, 0xE3, 0x36,
    0x19, 0xCC, 0x66, 0xB3, 0xE7, 0x32, 0x98, 0x4D, 0x30, 0xE5, 0x4F, 0x9A, 0xCE, 0x1B, 0xB1, 0x64,
    0x72, 0xA7, 0x0D, 0xD8, 0x8C, 0x59, 0xF3, 0x26, 0x5B, 0x8E, 0x24, 0xF1, 0xA5, 0x70, 0xDA, 0x0F,
    0x20, 0xF5, 0x5F, 0x8A, 0xDE, 0x0B, 0xA1, 0x74, 0x09, 0xDC, 0x76, 0xA3, 0xF7, 0x22, 0x88, 0x5D,
    0xD6, 0x03, 0xA9, 0x7C, 0x28, 0xFD, 0x57, 0x82, 0xFF, 0x2A, 0x80, 0x55, 0x01, 0xD4, 0x7E, 0xAB,
    0x84, 0x51, 0xFB, 0x2E, 0x7A, 0xAF, 0x05, 0xD0, 0xAD, 0x78, 0xD2, 0x07, 0x53, 0x86, 0x2C, 0xF9};

}  // namespace

uint8_t crc8(const uint8_t *ptr, uint8_t len) {
    uint8_t crc = 0;
    for (uint8_t i = 0; i < len; i++)
        crc = crsf_crc8tab[crc ^ *ptr++];
    return crc;
}

void prepareDataPacket(uint8_t packet[26], const int16_t channels16[16]) {
    packet[0] = SIMPLETX_SYNTH_ADDR;
    packet[1] = 24;
    packet[2] = TYPE_CHANNELS;
    packet[3] = (uint8_t)(channels16[0] & 0x07FF);
    packet[4] = (uint8_t)(((channels16[0] & 0x07FF) >> 8) | ((channels16[1] & 0x07FF) << 3));
    packet[5] = (uint8_t)(((channels16[1] & 0x07FF) >> 5) | ((channels16[2] & 0x07FF) << 6));
    packet[6] = (uint8_t)((channels16[2] & 0x07FF) >> 2);
    packet[7] = (uint8_t)(((channels16[2] & 0x07FF) >> 10) | ((channels16[3] & 0x07FF) << 1));
    packet[8] = (uint8_t)(((channels16[3] & 0x07FF) >> 7) | ((channels16[4] & 0x07FF) << 4));
    packet[9] = (uint8_t)(((channels16[4] & 0x07FF) >> 4) | ((channels16[5] & 0x07FF) << 7));
    packet[10] = (uint8_t)((channels16[5] & 0x07FF) >> 1);
    packet[11] = (uint8_t)(((channels16[5] & 0x07FF) >> 9) | ((channels16[6] & 0x07FF) << 2));
    packet[12] = (uint8_t)(((channels16[6] & 0x07FF) >> 6) | ((channels16[7] & 0x07FF) << 5));
    packet[13] = (uint8_t)((channels16[7] & 0x07FF) >> 3);
    packet[14] = (uint8_t)(channels16[8] & 0x07FF);
    packet[15] = (uint8_t)(((channels16[8] & 0x07FF) >> 8) | ((channels16[9] & 0x07FF) << 3));
    packet[16] = (uint8_t)(((channels16[9] & 0x07FF) >> 5) | ((channels16[10] & 0x07FF) << 6));
    packet[17] = (uint8_t)((channels16[10] & 0x07FF) >> 2);
    packet[18] = (uint8_t)(((channels16[10] & 0x07FF) >> 10) | ((channels16[11] & 0x07FF) << 1));
    packet[19] = (uint8_t)(((channels16[11] & 0x07FF) >> 7) | ((channels16[12] & 0x07FF) << 4));
    packet[20] = (uint8_t)(((channels16[12] & 0x07FF) >> 4) | ((channels16[13] & 0x07FF) << 7));
    packet[21] = (uint8_t)((channels16[13] & 0x07FF) >> 1);
    packet[22] = (uint8_t)(((channels16[13] & 0x07FF) >> 9) | ((channels16[14] & 0x07FF) << 2));
    packet[23] = (uint8_t)(((channels16[14] & 0x07FF) >> 6) | ((channels16[15] & 0x07FF) << 5));
    packet[24] = (uint8_t)((channels16[15] & 0x07FF) >> 3);
    packet[25] = crc8(&packet[2], packet[1] - 1);
}

void prepareDataPacketFrom8Us(uint8_t packet[26], const uint16_t channels_us8[8], int16_t default_aux_us) {
    int16_t c[16];
    for (int i = 0; i < 8; i++)
        c[i] = (int16_t)channels_us8[i];
    for (int i = 8; i < 16; i++)
        c[i] = default_aux_us;
    prepareDataPacket(packet, c);
}

void prepareCmdPacket(uint8_t packetCmd[8], uint8_t command, uint8_t value) {
    packetCmd[0] = SIMPLETX_SYNTH_ADDR;
    packetCmd[1] = 6;
    packetCmd[2] = TYPE_SETTINGS_WRITE;
    packetCmd[3] = SIMPLETX_SYNTH_ADDR;
    packetCmd[4] = ADDR_RADIO;
    packetCmd[5] = command;
    packetCmd[6] = value;
    packetCmd[7] = crc8(&packetCmd[2], packetCmd[1] - 1);
}

}  // namespace simpletx_crsf
